options:
  parameters:
    author: wpc
    generate_options: qt_gui
    id: GMSKGEN
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/wpc/projects/Monarch-Ground-Station/prng1.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/wpc/projects/Monarch-Ground-Station/prng0.c64
    type: complex
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /home/wpc/projects/Monarch-Ground-Station/preambleg.c64
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wpc/projects/Monarch-Ground-Station/prn1.raw
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/wpc/projects/Monarch-Ground-Station/prn0.raw
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: /home/wpc/projects/Monarch-Ground-Station/preamble.raw
    repeat: 'False'
    type: byte
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.25'
    samples_per_symbol: '4'
    sensitivity: '1.0'
  states: {state: disabled}
- name: digital_gfsk_mod_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.25'
    samples_per_symbol: '4'
    sensitivity: '1.0'
  states: {state: disabled}
- name: digital_gfsk_mod_1
  id: digital_gfsk_mod
  parameters:
    bt: '0.25'
    samples_per_symbol: '4'
    sensitivity: '1.0'
  states: {state: disabled}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.25'
    samples_per_symbol: '4'
  states: {}
- name: digital_gmsk_mod_0_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.25'
    samples_per_symbol: '4'
  states: {}
- name: digital_gmsk_mod_0_1
  id: digital_gmsk_mod
  parameters:
    bt: '0.25'
    samples_per_symbol: '4'
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gfsk_mod_0, '0']
- [blocks_file_source_0, '0', digital_gmsk_mod_0, '0']
- [blocks_file_source_0_0, '0', digital_gfsk_mod_1, '0']
- [blocks_file_source_0_0, '0', digital_gmsk_mod_0_0, '0']
- [blocks_file_source_0_1, '0', digital_gfsk_mod_0_0, '0']
- [blocks_file_source_0_1, '0', digital_gmsk_mod_0_1, '0']
- [digital_gfsk_mod_0, '0', blocks_file_sink_0, '0']
- [digital_gfsk_mod_0_0, '0', blocks_file_sink_0_1, '0']
- [digital_gfsk_mod_1, '0', blocks_file_sink_0_0, '0']
- [digital_gmsk_mod_0, '0', blocks_file_sink_0, '0']
- [digital_gmsk_mod_0_0, '0', blocks_file_sink_0_0, '0']
- [digital_gmsk_mod_0_1, '0', blocks_file_sink_0_1, '0']

metadata:
  file_format: 1
